# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Init.c Init.h Key.c Key.h Seg.c Seg.h Led.c Led.h STC15F2K60S2.h ds1302.c iic.c onewire.c ds1302.h iic.h onewire.h ultrasonic.c ultrasonic.h
